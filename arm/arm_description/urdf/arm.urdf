Commit message: update

File: arm/arm_description/urdf/arm.urdf (robot description, URDF)
Before this commit: robot arm, 4 links, 3 joints
Links:
- link link1: mass None -> 0.1
- link link2: mass None -> 0.1
