Commit message: update repo

File: arm/arm/urdf/arm.urdf (robot description, URDF)
Before this commit: robot arm, 3 links, 2 joints
Joints:
- joint joint2: limit lower=-0.59 upper=0.6 effort=0 velocity=0 -> lower=0 upper=0.5 effort=0 velocity=0
